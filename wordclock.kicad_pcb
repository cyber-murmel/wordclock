# Repository cyber-murmel/wordclock

## KiCad design wordclock.kicad_pcb

Parts:
BT1: Battery_Cell; Keystone_1058_1x2032-CoinCell
C1: 470uF; CP_Radial_D6.3mm_P2.50mm
C2, C3, C4, C5: 100n; C_Disc_D3.0mm_W1.6mm_P2.50mm
CON1: AVR-ISP-6; IDC_Header_Straight_6pins
D1: Green; LED_D3.0mm
IC1: ATMEGA168PA-PU; DIP-28_W7.62mm_Socket_LongPads
IC2: DS1307+; DIP-8_W7.62mm_Socket_LongPads
J1: UAR7; Pin_Header_Straight_1x04_Pitch2.54mm
J2: Jack-DC; BARREL_JACK
J3: Neo Pixel; TerminalBlock_Philmore_TB133_03x5mm_Straight
R1, R2, R7, R8: 10k; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R4, R5: 4.7k; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
R6: 330R; R_Axial_DIN0204_L3.6mm_D1.6mm_P7.62mm_Horizontal
SW1, SW2: SW_Push; SW_PUSH_6mm
Y1: 16MHz; Resonator-3pin_w7.0mm_h2.5mm
Y2: 32.7680kHz; Crystal_C18-LF_d3.0mm_l8.0mm_Horizontal

Connections:
+5V: C1.1, C3.1, C4.1, CON1.2, D1.2 (A), IC1.7, IC1.20, IC2.8 (VCC), J2.1, J3.3, R1.2, R4.1, R5.1, SW1.1, SW2.1
/MISO: CON1.1, IC1.18
/MOSI: CON1.4, IC1.17
/R7S: C2.2, J1.4
/RST: C2.1, CON1.5, IC1.1, R1.1
/RX: IC1.2, J1.3
/SCK: CON1.3, IC1.19
/SCL: IC1.28, IC2.6 (SCL), R5.2
/SDA: IC1.27, IC2.5 (SDA), R4.2
/TX: IC1.3, J1.2
COLOR: IC1.5, R8.2, SW2.2
GND: BT1.2 (-), C1.2, C3.2, C4.2, C5.2, CON1.6, IC1.8, IC1.22, IC2.4 (GND), J1.1, J2.2, J2.3, J3.1, R2.2, R7.1, R8.1, Y1.2
unnamed: BT1.1 (+), IC2.3 (VBAT)
unnamed: C5.1, IC1.21
unnamed: D1.1 (K), R2.1
unnamed: IC1.9, Y1.3
unnamed: IC1.10, Y1.1
unnamed: IC2.1 (XTAL1), Y2.1
unnamed: IC2.2 (XTAL2), Y2.2
unnamed: J3.2, R6.1
TIME: IC1.4, R7.2, SW1.2
WS2812: IC1.6, R6.2

Notes on the sheet:
Real Time Clock
WS2812 RGB LEDs
Programming & Debugging
Buttons
Power
Brain

Board: 2 copper layers, 33.0 x 63.5 mm, 24 parts (1 on the bottom side), 22 nets.

## Commit log

2018-01-23 add OpenSCAD files
2018-01-23 cheanges in wordclock pcb files
2018-01-23 added ignore file
2018-01-23 adds arduino code for english and germen version
2018-01-23 working code
2018-01-23 moves pcb files into seperate direcotry
